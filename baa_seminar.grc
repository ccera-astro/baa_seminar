options:
  parameters:
    generate_options: qt_gui
    id: baa_seminar
    output_language: python
    run_options: run
  states: {}

blocks:
- name: actual_freq
  id: variable
  parameters:
    value: ifreq if is_usrp == False else uhd.tune_request(ifreq, samp_rate/2)
  states: {}
- name: correct_baseline
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: Main@1:0,0
    label: Baseline Correction
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: data_rate
  id: variable
  parameters:
    comment: |-
      The "back end" operates at this many Hz
      20Hz should be more than adequate for
      any data-logging requirements for this
      type of observing
    value: '10'
  states: {}
- name: dc_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@3:0,0
    label: '"Detector Output Mult."'
    min_len: '100'
    orient: Qt.Horizontal
    start: '1'
    step: '10'
    stop: '1000'
    value: dmult
    widget: counter
  states: {}
- name: dophigh
  id: variable
  parameters:
    value: ((samp_rate/2.0)/ifreq)*299792.0
  states: {}
- name: doplow
  id: variable
  parameters:
    value: '-((samp_rate/2.0)/ifreq)*299792.0'
  states: {}
- name: fftrate
  id: variable
  parameters:
    value: int(samp_rate/fftsize)
  states: {}
- name: fftsize
  id: variable
  parameters:
    comment: |-
      We make this a variable, but in reality
      Embedded Python blocks
      dont handle runtime vector sizing very well
    value: '2048'
  states: {}
- name: fper
  id: variable
  parameters:
    comment: |-
      Compute fringe period from baseline length
      center frequency and declination
    value: ra_funcs.fperiod(ifreq,ibaseline,idecln,0.0)
  states: {}
- name: freqlow
  id: variable
  parameters:
    value: (ifreq-(samp_rate/2.0))/1.0e6
  states: {}
- name: freqstep
  id: variable
  parameters:
    value: (samp_rate/fftsize)/1.0e6
  states: {}
- name: gmt
  id: variable
  parameters:
    value: time.gmtime()
  states: {}
- name: iangEast
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@3:4,0,1,2
    label: Phase Correction East
    min_len: '400'
    orient: Qt.Horizontal
    start: '-180.0'
    step: '2.0'
    stop: '180.0'
    value: angleEast
  states: {}
- name: iangWest
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@3:4,2,1,2
    label: Phase Correction West
    min_len: '400'
    orient: Qt.Horizontal
    start: '-180.0'
    step: '2.0'
    stop: '180.0'
    value: angleWest
  states: {}
- name: ibaseline
  id: variable_qtgui_entry
  parameters:
    gui_hint: Main@3:2,2
    label: Baseline Length
    type: real
    value: baseline
  states: {}
- name: idceast
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@3:6,0,1,2
    label: DC Offset East
    min_len: '400'
    orient: Qt.Horizontal
    start: '-0.01'
    step: '0.0001'
    stop: '0.01'
    value: dceast
  states: {}
- name: idcwest
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@3:6,2,1,2
    label: DC Offset West
    min_len: '400'
    orient: Qt.Horizontal
    start: '-0.01'
    step: '0.0001'
    stop: '0.01'
    value: dceast
  states: {}
- name: idecln
  id: variable_qtgui_entry
  parameters:
    gui_hint: Main@3:2,1
    label: Declination
    type: real
    value: declination
  states: {}
- name: ifreq
  id: variable_qtgui_entry
  parameters:
    gui_hint: Main@3:1,0
    label: Tuned Frequency
    type: real
    value: freq
  states: {}
- name: ihighpass
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: Main@3:0,3
    label: Enable differential high pass
    'true': '1'
    type: int
    value: highpass
  states: {}
- name: imulEast
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@3:5,0
    label: Gain Correction East
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.01'
    stop: '1.5'
    value: mulEast
    widget: counter
  states: {}
- name: imulWest
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@3:5,1
    label: Gain Correction West
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.01'
    stop: '1.5'
    value: mulWest
    widget: counter
  states: {}
- name: irfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@3:1,1
    label: RF Gain
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '2.5'
    stop: '100'
    value: rfgain
    widget: counter
  states: {}
- name: is_usrp
  id: variable
  parameters:
    value: '"uhd" in device'
  states: {}
- name: isinteg
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@3:0,2
    label: Spectral Integration Time
    min_len: '100'
    orient: Qt.Horizontal
    start: '1'
    step: '10'
    stop: '1000'
    value: sinteg
    widget: counter
  states: {}
- name: itinteg
  id: variable_qtgui_range
  parameters:
    gui_hint: Main@3:0,1
    label: TP Integration Time
    min_len: '100'
    orient: Qt.Horizontal
    start: '1'
    step: '10'
    stop: '500'
    value: tinteg
    widget: counter
  states: {}
- name: pacer
  id: variable_function_probe
  parameters:
    block_id: pacer_probe
    comment: |-
      A bit of a hack to get us an LMST
      display that is updated at 1Hz
    function_name: level
    poll_rate: '1'
    value: '0.0'
  states: {}
- name: phaseEast
  id: variable
  parameters:
    value: complex(math.cos(math.radians(iangEast)),math.sin(math.radians(iangEast)))
  states: {}
- name: phaseWest
  id: variable
  parameters:
    value: complex(math.cos(math.radians(iangWest)),math.sin(math.radians(iangWest)))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(srate)
  states: {}
- name: split_ratio
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tiktok
  id: variable
  parameters:
    value: pacer*0.0
  states: {}
- name: today
  id: variable
  parameters:
    value: '"%04d-%02d-%02d" % (gmt.tm_year, gmt.tm_mon, gmt.tm_mday)'
  states: {}
- name: tunereq
  id: variable
  parameters:
    value: uhd.tune_request(ifreq,samp_rate*1.8)
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,2
    label: LMST
    type: string
    value: ra_funcs.cur_sidereal(longitude+tiktok).replace(",",":")
  states: {}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: Main@3:2,0
    label: Logging to...
    type: string
    value: prefix
  states: {}
- name: variable_qtgui_label_0_1
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,3
    label: title
    type: string
    value: today
  states: {}
- name: variable_qtgui_label_0_1_0
  id: variable_qtgui_label
  parameters:
    gui_hint: Main@3:2,4
    label: Fringe Period
    type: string
    value: '"%5d secs" % fper'
  states: {}
- name: winpower
  id: variable
  parameters:
    value: sum([x*x for x in window.blackman_harris(fftsize)])
  states: {}
- name: Main
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,4,4
    label0: Total Power
    label1: Spectral
    label2: Correlation
    label3: Controls
    num_tabs: '4'
  states: {}
- name: angleEast
  id: parameter
  parameters:
    label: Phase Corr. Angle EAST
    type: eng_float
    value: '0.0'
  states: {}
- name: angleWest
  id: parameter
  parameters:
    label: Phase Corr. Angle WEST
    type: eng_float
    value: '0.0'
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: '"Antenna Selection"'
    type: str
    value: '""'
  states: {}
- name: baseline
  id: parameter
  parameters:
    label: Interferometer Baseline (meters)
    type: eng_float
    value: '4.0'
  states: {}
- name: baseline_compensate
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Baseline compensator block
               Takes in an integrated FFT vector and either outputs that vector, or
               outputs a baseline-subtracted version of that vector
               
               fftsize - size of input vector
               collect - operate in "collect" rather than compensate mode
          """

          def __init__(self, fftsize=2048,collect=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BAA:Baseline Compensator',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=[(np.float32,fftsize)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.collect = collect
              self.fftbuf = np.zeros(fftsize,dtype=np.float32)

          def work(self, input_items, output_items):
              """Accumulate baseline data, apply corrections when asked"""
              if (self.collect == True):
                  #
                  # Collect samples, and compute a moving average on them
                  # They're already fairly-well smoothed, so we don't
                  # need to go overboard
                  #
                  for x in range(len(input_items[0])):
                      self.fftbuf = np.add(self.fftbuf, input_items[0][x])
                      self.fftbuf = np.divide(self.fftbuf, [2.0]*len(self.fftbuf))
                  self.avg = sum(self.fftbuf)/len(self.fftbuf)
                  self.avg *= 1.5
                  
                  for x in range(len(output_items[0])):
                      output_items[0][x] = input_items[0][x]
              else:
                  for x in range(len(output_items[0])):
                      output_items[0][x] = np.subtract(input_items[0][x], self.fftbuf)
                      output_items[0][x] = np.add(output_items[0][x], self.avg)
              
              return len(output_items[0])
    collect: True if correct_baseline == False else False
    comment: Optionally apply baseline-subtraction
    fftsize: fftsize
  states: {}
- name: baseline_compensate_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Baseline compensator block
               Takes in an integrated FFT vector and either outputs that vector, or
               outputs a baseline-subtracted version of that vector
               
               fftsize - size of input vector
               collect - operate in "collect" rather than compensate mode
          """

          def __init__(self, fftsize=2048,collect=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BAA:Baseline Compensator',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=[(np.float32,fftsize)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.collect = collect
              self.fftbuf = np.zeros(fftsize,dtype=np.float32)

          def work(self, input_items, output_items):
              """Accumulate baseline data, apply corrections when asked"""
              if (self.collect == True):
                  #
                  # Collect samples, and compute a moving average on them
                  # They're already fairly-well smoothed, so we don't
                  # need to go overboard
                  #
                  for x in range(len(input_items[0])):
                      self.fftbuf = np.add(self.fftbuf, input_items[0][x])
                      self.fftbuf = np.divide(self.fftbuf, [2.0]*len(self.fftbuf))
                  self.avg = sum(self.fftbuf)/len(self.fftbuf)
                  self.avg *= 1.5
                  
                  for x in range(len(output_items[0])):
                      output_items[0][x] = input_items[0][x]
              else:
                  for x in range(len(output_items[0])):
                      output_items[0][x] = np.subtract(input_items[0][x], self.fftbuf)
                      output_items[0][x] = np.add(output_items[0][x], self.avg)
              
              return len(output_items[0])
    collect: True if correct_baseline == False else False
    comment: Optionally apply baseline-subtraction
    fftsize: fftsize
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Because 2nd input could be zeros
      We want to add a little bit so that
      log10 doesn't throw exceptions
    const: '[1.0e-14]*fftsize if "file=" in device else [0.0]*fftsize'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: idceast
    type: complex
  states: {}
- name: blocks_add_const_vxx_1_0
  id: blocks_add_const_vxx
  parameters:
    const: idcwest
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: SUM
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: |-
      A detector
      Computes
      (I^2)+(Q^2)
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: |-
      A detector
      Computes
      (I^2)+(Q^2)
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Convert to power estimate
    vlen: fftsize
  states: {}
- name: blocks_complex_to_mag_squared_1_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Convert to power estimate
    vlen: fftsize
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: split_ratio
    type: float
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: split_ratio
    type: complex
  states: {}
- name: blocks_integrate_xx_0_1
  id: blocks_integrate_xx
  parameters:
    decim: split_ratio
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      After filtering, we don't need high
      sample rates
      reduce to 'data_rate' Hz
    n: int(int(samp_rate/data_rate)/split_ratio)
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      After filtering, we don't need high
      sample rates
      reduce to 'data_rate' Hz
    n: int(int(samp_rate/data_rate)/split_ratio)
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_1
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      After filtering, we don't need high
      sample rates
      reduce to 'data_rate' Hz
    n: int(int(samp_rate/data_rate)/split_ratio)
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_2
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      After filtering, we don't need high
      sample rates
      reduce to 'data_rate' Hz
    n: int(int(samp_rate/data_rate)/split_ratio)
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_2_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      After filtering, we don't need high
      sample rates
      reduce to 'data_rate' Hz
    n: int(int(samp_rate/data_rate)/split_ratio)
    type: float
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    comment: Decimate
    n: int(fftrate/data_rate)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_keep_one_in_n_1_0
  id: blocks_keep_one_in_n
  parameters:
    comment: Decimate
    n: int(fftrate/data_rate)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Apply the detector-multiplier
    const: float(dc_gain*10)
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: Integrator doesn't reduce
    const: (1.0/split_ratio)*dc_gain
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    comment: Integrator doesn't reduce
    const: 1.0/split_ratio
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_1
  id: blocks_multiply_const_xx
  parameters:
    comment: Integrator doesn't reduce
    const: (1.0/split_ratio)*dc_gain
    type: float
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: imulEast*phaseEast
    type: complex
  states: {}
- name: blocks_multiply_const_xx_1_0
  id: blocks_multiply_const_xx
  parameters:
    const: imulWest*phaseWest
    type: complex
  states: {}
- name: blocks_multiply_const_xx_2
  id: blocks_multiply_const_xx
  parameters:
    const: ihighpass
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Turn into 10Log10
      Then scale appropriately
    k: '-20*math.log10(fftsize)-10*math.log10(winpower/fftsize)'
    n: '10'
    vlen: fftsize
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Turn into 10Log10
      Then scale appropriately
    k: '-20*math.log10(fftsize)-10*math.log10(winpower/fftsize)'
    n: '10'
    vlen: fftsize
  states: {}
- name: blocks_patterned_interleaver_0
  id: blocks_patterned_interleaver
  parameters:
    pattern: '[0,1,2,3,4,5]'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      FFT requires fft-sized vectors
      we do that here
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      FFT requires fft-sized vectors
      we do that here
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    comment: DIFFERENCE
    type: float
  states: {}
- name: blocks_sub_xx_1_0
  id: blocks_sub_xx
  parameters:
    comment: HP subtractor
    type: float
  states: {}
- name: bw
  id: parameter
  parameters:
    label: '"Analog Bandwidth"'
    type: eng_float
    value: '0.0'
  states: {}
- name: comp
  id: parameter
  parameters:
    label: DC/IQ compensation mode
    type: intx
    value: '0'
  states: {}
- name: dceast
  id: parameter
  parameters:
    label: East DC correction
    type: eng_float
    value: '0.0'
  states: {}
- name: dcwest
  id: parameter
  parameters:
    label: West DC Correction
    type: eng_float
    value: '0.0'
  states: {}
- name: declination
  id: parameter
  parameters:
    label: Object Declination
    type: eng_float
    value: '45.0'
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device string
    type: str
    value: '"rtl=0 rtl=1"'
  states: {}
- name: dmult
  id: parameter
  parameters:
    label: Detector Multiplier
    type: eng_float
    value: '1'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: flipper
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Flipper -- simply reverse the order of a vector
                     fftsize - size of the (probably FFT) vector
                     enabled - whether to flip or not
          """

          def __init__(self, fftsize=2048,enabled=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BAA:Flipper',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=[(np.float32,fftsize)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.enabled = enabled

          def work(self, input_items, output_items):
              """Flip order"""
              
              #
              # For each output item
              #
              # Either stuff it with flipped input, or non-flipped input
              #
              for x in range(len(output_items[0])):
                  if (self.enabled == True):
                      output_items[0][x] = input_items[0][x][::-1]
                  else:
                      output_items[0][x] = input_items[0][x]
              return len(output_items[0])
    comment: |-
      Optionally flip the spectral vector for
      display--for conventional display of
      redshift/blueshift
    enabled: True if velocity != 0 else False
    fftsize: fftsize
  states: {}
- name: flipper_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Flipper -- simply reverse the order of a vector
                     fftsize - size of the (probably FFT) vector
                     enabled - whether to flip or not
          """

          def __init__(self, fftsize=2048,enabled=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BAA:Flipper',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=[(np.float32,fftsize)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.enabled = enabled

          def work(self, input_items, output_items):
              """Flip order"""
              
              #
              # For each output item
              #
              # Either stuff it with flipped input, or non-flipped input
              #
              for x in range(len(output_items[0])):
                  if (self.enabled == True):
                      output_items[0][x] = input_items[0][x][::-1]
                  else:
                      output_items[0][x] = input_items[0][x]
              return len(output_items[0])
    comment: |-
      Optionally flip the spectral vector for
      display--for conventional display of
      redshift/blueshift
    enabled: True if velocity != 0 else False
    fftsize: fftsize
  states: {}
- name: formatter
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import ra_funcs


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """A slow data textual formatter
                inputs are expected to be science-data
                   Parameters:
                      formatter - pointer to a custom formatter function
                      filepat - pattern used for formatting filename must provide converters for YYYY MM DD
                      extension - filename extension
                      logtime - how often to log, in seconds
                      fmtstr - formatter for data values -- most provide converters for both values
                      nchan - number of interleaved channels on input"""
                      
                      

          def __init__(self, formatter=None, filepat="foonly-%d%d%d", extension=".csv", 
              logtime=10,fmtstr="%11.9f",nchan=1,localtime=False,longitude=-76.03, legend=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BAA:Data Logger',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #
              # Formatter is a function pointer--very often 'None'
              #
              self.formatter = formatter
              
              #
              # Controls the template for filename generation
              #
              self.filepat= filepat
              
              #
              # The filename extension
              #
              self.extension=extension
              
              #
              # The logging interval
              #
              self.logtime=logtime
              
              
              #
              # The data-item formatting string
              #      
              self.fmtstr = fmtstr
              
              #
              # How many (interleaved) channels
              self.nchan = nchan
              
              #
              # Use local time, rather than UTC/GMT?
              #
              self.localtime = localtime
              
              #
              # The averaing cells
              #
              self.avg = [0.0]*nchan
              self.acnt = [0]*nchan

              
              #
              # Keep track of the next channel's averaging cell we
              #  need to update
              #
              self.cndx = 0
              
              
              #
              # This isn't strictly required, since the work function code
              #  will take care of whatever items it gets presented with.
              #
              self.set_output_multiple(nchan)
              
              self.now = time.time()
              
              self.longitude = longitude
              
              self.legend = legend
              
              self.legcount = 0
              self.fn = ""
              self.curlegend = legend

          def work(self, input_items, output_items):
              
              if (self.localtime == False):
                  ltp = time.gmtime()
              else:
                  ltp = time.localtime()
              
              #
              # Distribute the input items over the averaging buffer as appropriate
              #  We assume that the input is interleaved by 'nchan'
              #  We use 'self.cndx' to keep track of which channel's averaging
              #  cell we need to put the next value in.
              #
              # Because GR's scheduler has no idea what our internal "shape"
              #  is, it can hand us many, or a few, items, every time we're
              #  called.
              #
              for x in range(len(input_items[0])):
                  self.avg[self.cndx % self.nchan] += input_items[0][x]
                  self.acnt[self.cndx % self.nchan] += 1
                  
                  #
                  # Increment and modularly reduce cndx
                  #
                  self.cndx += 1
                  self.cndx %= self.nchan
                  

              if ((time.time() - self.now) > self.logtime):
                  self.now = time.time()
                  if (self.formatter == None):
                      fn = self.filepat % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday) + self.extension
                      fp = open(fn, "a")
                      #
                      # Filename has changed (new date) or
                      #  legend has changed (new DEC/FREQ/BW) or
                      #  legcount >= 30
                      #
                      wrlegend = False
                      if (self.fn != fn):
                          self.fn = fn
                          wrlegend = True
                      elif (self.curlegend != self.legend):
                          self.curlegend = self.legend
                          wrlegend = True
                      elif (self.legcount >= 30):
                          wrlegend = True
                          self.legcount = 0
                      if (wrlegend == True and self.legend != None):
                          self.legcount = 0
                          fp.write("INFO:%s\n" % self.legend)
                          
                      fp.write("%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                      fp.write("%s," % ra_funcs.cur_sidereal(self.longitude))
                      for x in range(self.nchan):
                          self.avg[x] /= self.acnt[x]
                          self.acnt[x] = 1
                          fp.write (self.fmtstr  % (self.avg[x]))
                          if (x < self.nchan-1):
                              fp.write(",")
                      fp.write("\n")
                      self.legcount += 1
                      
                          
                      fp.close()
        
                  else:
                      self.formatter(self.filepat,self.extension,self.avg[0],self.avg[1])
                  
              return len(input_items[0])
    extension: '''.csv'''
    filepat: prefix+'tp-%04d%02d%02d'
    fmtstr: '''%11.9f'''
    formatter: None
    legend: '"Sum,Corr(R),Corr(I),Diff,East,West,DEC=%f,FREQ=%f,BW=%f" % (idecln, ifreq/1.0e6, srate/1.0e6)'
    localtime: False if utc != 0 else True
    logtime: logtime
    longitude: longitude
    nchan: '6'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: RF Frequency (Hz)
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: highpass
  id: parameter
  parameters:
    label: HIgh pass for differential pathway
    type: intx
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import ra_funcs
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: from gnuradio import uhd
  states: {}
- name: logtime
  id: parameter
  parameters:
    label: Logging Interval (secs)
    type: eng_float
    value: '5.0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: Longitude
    type: eng_float
    value: '-76.03'
  states: {}
- name: mulEast
  id: parameter
  parameters:
    label: A channel balance multiplier
    type: eng_float
    value: '1.0'
  states: {}
- name: mulWest
  id: parameter
  parameters:
    label: B channel balance multiplier
    type: eng_float
    value: '1.0'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The spectral sub-graph
      Compute the mag^2
      Integrate
      Decimate down to "data_rate"
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      The total-power sub-graph
      Compute mag^2 for both inputs
      (East and West)
      Provide East and West outputs
      as well as sum and difference
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      The correlation sub-graph
      Compute the conjugate product
      Integrate
      Decimate down to "data_rate"
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      The correlator sub-graph
      It assumes both halves
      (East and West)
      Are equal-phase in the analog sense

      Otherewise you'd need to add delay
      and phase adjust blocks.
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      There are 32-bit-float numerical
      issues when using very-small ALPHA
      values in the IIR.
      So, we do the integration in two stages.
  states: {}
- name: note_3
  id: note
  parameters:
    comment: |-
      We implement a high-pass filter, cheaply
      This allows us to remove any DC offset in
      the correlation.
  states: {}
- name: note_4
  id: note
  parameters:
    comment: |-
      A simple high-pass for the differential
      pathway--if using differential interferometry,
      a high pass can help with DC gain drift.
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: antenna
    ant1: antenna
    args: device
    bb_gain0: '0'
    bb_gain1: '0'
    bw0: (int((samp_rate*0.8)) if bw == 0 else int(bw)) if is_usrp == False else (samp_rate*0.8+(samp_rate/1.8))
    bw1: (int((samp_rate*0.8)) if bw == 0 else int(bw)) if is_usrp == False else (samp_rate*0.8+(samp_rate/1.8))
    corr1: '0'
    dc_offset_mode0: comp
    dc_offset_mode1: comp
    freq0: actual_freq
    freq1: actual_freq
    gain0: irfgain
    gain1: irfgain
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '0'
    if_gain1: '0'
    iq_balance_mode0: comp
    iq_balance_mode1: comp
    nchan: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: pacer_probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: File prefix
    type: str
    value: '"./"'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    color4: '"magenta"'
    grid: 'True'
    gui_hint: Main@0:0,0,1,4
    label1: Detector (Sum)
    label2: Detector (Difference)
    label3: Detector(East)
    label4: Detector(West)
    name: '"Total Power/Diff. Power"'
    nconnections: '4'
    showports: 'True'
    update_time: '0.250'
    vlen: seconds
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    x_axis_label: '"Time (Seconds)"'
    x_start: '0'
    x_step: '1'
    x_units: Secs
    y_axis_label: '"Detector Power"'
    ymax: '1.5'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: Main@2:0,0,1,4
    label1: COS
    label2: SIN
    name: Correlator Output
    nconnections: '2'
    showports: 'True'
    update_time: '0.250'
    vlen: seconds
    width1: '2'
    width2: '2'
    x_axis_label: '"Time (Seconds)"'
    x_start: '0'
    x_step: '1'
    x_units: Secs
    y_axis_label: '"Cross Power"'
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: Main@1:1,0
    label1: '"Spectrum East"'
    label2: '"Spectrum West"'
    name: '"Doppler Velocity" if velocity == True else "Frequency"'
    nconnections: '2'
    update_time: 1.0/(data_rate)
    vlen: fftsize
    x_axis_label: '"Red shift(km/s)" if velocity == True else "Frequency (MHz)"'
    x_start: doplow if velocity == True else freqlow
    x_step: (dophigh-doplow)/fftsize if velocity == True else freqstep
    x_units: '"km/s" if velocity == True else "MHz"'
    y_axis_label: Rel power (dB)
    y_units: dB
    ymin: '-100'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain (dB)
    type: eng_float
    value: '40'
  states: {}
- name: seconds
  id: parameter
  parameters:
    label: Strip chart length, seconds
    type: intx
    value: '3600'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/itinteg,samp_rate/split_ratio)
    comment: A simple filter/integrator
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/itinteg,samp_rate/split_ratio)
    comment: A simple filter/integrator
    type: complex
  states: {}
- name: single_pole_iir_filter_xx_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/(fper*1.25),samp_rate/split_ratio)
    comment: |-
      A simple filter/integrator
      The lower path helps us make
      a high-pass filter
    type: complex
  states: {}
- name: single_pole_iir_filter_xx_0_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/itinteg,samp_rate/split_ratio)
    comment: A simple filter/integrator
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_1_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/(fper*1.25),samp_rate/split_ratio)
    comment: |-
      A simple filter/integrator
      Bottom half of high-pass
      Assume 15-minute corner for now
    type: float
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/isinteg,fftrate)
    comment: Integrate
    type: float
    vlen: fftsize
  states: {}
- name: single_pole_iir_filter_xx_1_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/isinteg,fftrate)
    comment: Integrate
    type: float
    vlen: fftsize
  states: {}
- name: sinteg
  id: parameter
  parameters:
    label: Integraton Time(secs) for Spectrum
    type: eng_float
    value: '10.0'
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate (SPS)
    type: eng_float
    value: 2.56e6
  states: {}
- name: stripchart
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """A strip chart takes in a stream of floats and produces a 1 hour long
             strip-chart as output
             
             Params:
                decim - how much to decimate input to produce 1 SPS
                seconds - how many seconds long is the stripchart vector
          """

          def __init__(self, decim=100,seconds=3600):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='BAA:Strip Chart',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32,seconds)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #
              # How much do we need to average the input to produce a 1SPS
              #  output?
              #
              self.decim = decim
              
              #
              # The stripchart vector itself--must be persistent in the
              #  object instance
              #
              self.strip = [0.0]*seconds
              
              #
              # keeps track of decimation
              #
              self.counter = 0
              
              #
              # We continuously average the input and store it here
              #
              self.avg = 0.0

          def general_work(self, input_items, output_items):
              """take an input item(s), place appropriately in stripchart output"""
       
              #
              # Our averager hasn't been initialized with a
              #  "prime the pump" value?
              # Do it now.
              #
              if (self.avg == 0.0):
                  self.avg = input_items[0][0]
                  self.counter = 0
                  #
                  # Also init the strip-chart to this level
                  #
                  self.strip = [self.avg]*len(self.strip)
              #
              # For each of the input items
              #
              for x in range(len(input_items[0])):
                  #
                  # Effectively we get a N-point moving average
                  # WHere "N" is "decim"
                  #
                  self.avg += input_items[0][x]
                  self.counter += 1
                  
                  #
                  # Time to output an item into the stripchart
                  #
                  if (self.counter >= self.decim):
                      
                      #
                      # Reduce by decim
                      #
                      self.avg /= self.counter
                      
                      #
                      # Use python array notation to effect a quick
                      #  shift of items in the stripchart array
                      #
                      self.strip = [self.avg] + self.strip[:-1]
                      self.counter = 0
                      self.avg = 1.0e-15
              #
              # Stuff output items with the contents of the 
              #  possibly-updated stripchart
              #
              for y in range(len(output_items[0])):
                  output_items[0][y] = self.strip
              
              #
              # Tell scheduler we consumed items
              #
              self.consume(0, len(input_items[0]))
              return len(output_items[0])
    comment: Produces a "stripchart" type vector
    decim: data_rate
    seconds: seconds
  states: {}
- name: stripchart_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """A strip chart takes in a stream of floats and produces a 1 hour long
             strip-chart as output
             
             Params:
                decim - how much to decimate input to produce 1 SPS
                seconds - how many seconds long is the stripchart vector
          """

          def __init__(self, decim=100,seconds=3600):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='BAA:Strip Chart',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32,seconds)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #
              # How much do we need to average the input to produce a 1SPS
              #  output?
              #
              self.decim = decim
              
              #
              # The stripchart vector itself--must be persistent in the
              #  object instance
              #
              self.strip = [0.0]*seconds
              
              #
              # keeps track of decimation
              #
              self.counter = 0
              
              #
              # We continuously average the input and store it here
              #
              self.avg = 0.0

          def general_work(self, input_items, output_items):
              """take an input item(s), place appropriately in stripchart output"""
       
              #
              # Our averager hasn't been initialized with a
              #  "prime the pump" value?
              # Do it now.
              #
              if (self.avg == 0.0):
                  self.avg = input_items[0][0]
                  self.counter = 0
                  #
                  # Also init the strip-chart to this level
                  #
                  self.strip = [self.avg]*len(self.strip)
              #
              # For each of the input items
              #
              for x in range(len(input_items[0])):
                  #
                  # Effectively we get a N-point moving average
                  # WHere "N" is "decim"
                  #
                  self.avg += input_items[0][x]
                  self.counter += 1
                  
                  #
                  # Time to output an item into the stripchart
                  #
                  if (self.counter >= self.decim):
                      
                      #
                      # Reduce by decim
                      #
                      self.avg /= self.counter
                      
                      #
                      # Use python array notation to effect a quick
                      #  shift of items in the stripchart array
                      #
                      self.strip = [self.avg] + self.strip[:-1]
                      self.counter = 0
                      self.avg = 1.0e-15
              #
              # Stuff output items with the contents of the 
              #  possibly-updated stripchart
              #
              for y in range(len(output_items[0])):
                  output_items[0][y] = self.strip
              
              #
              # Tell scheduler we consumed items
              #
              self.consume(0, len(input_items[0]))
              return len(output_items[0])
    comment: Produces a "stripchart" type vector
    decim: data_rate
    seconds: seconds
  states: {}
- name: stripchart_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """A strip chart takes in a stream of floats and produces a 1 hour long
             strip-chart as output
             
             Params:
                decim - how much to decimate input to produce 1 SPS
                seconds - how many seconds long is the stripchart vector
          """

          def __init__(self, decim=100,seconds=3600):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='BAA:Strip Chart',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32,seconds)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #
              # How much do we need to average the input to produce a 1SPS
              #  output?
              #
              self.decim = decim
              
              #
              # The stripchart vector itself--must be persistent in the
              #  object instance
              #
              self.strip = [0.0]*seconds
              
              #
              # keeps track of decimation
              #
              self.counter = 0
              
              #
              # We continuously average the input and store it here
              #
              self.avg = 0.0

          def general_work(self, input_items, output_items):
              """take an input item(s), place appropriately in stripchart output"""
       
              #
              # Our averager hasn't been initialized with a
              #  "prime the pump" value?
              # Do it now.
              #
              if (self.avg == 0.0):
                  self.avg = input_items[0][0]
                  self.counter = 0
                  #
                  # Also init the strip-chart to this level
                  #
                  self.strip = [self.avg]*len(self.strip)
              #
              # For each of the input items
              #
              for x in range(len(input_items[0])):
                  #
                  # Effectively we get a N-point moving average
                  # WHere "N" is "decim"
                  #
                  self.avg += input_items[0][x]
                  self.counter += 1
                  
                  #
                  # Time to output an item into the stripchart
                  #
                  if (self.counter >= self.decim):
                      
                      #
                      # Reduce by decim
                      #
                      self.avg /= self.counter
                      
                      #
                      # Use python array notation to effect a quick
                      #  shift of items in the stripchart array
                      #
                      self.strip = [self.avg] + self.strip[:-1]
                      self.counter = 0
                      self.avg = 1.0e-15
              #
              # Stuff output items with the contents of the 
              #  possibly-updated stripchart
              #
              for y in range(len(output_items[0])):
                  output_items[0][y] = self.strip
              
              #
              # Tell scheduler we consumed items
              #
              self.consume(0, len(input_items[0]))
              return len(output_items[0])
    comment: Produces a "stripchart" type vector
    decim: data_rate
    seconds: seconds
  states: {}
- name: stripchart_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """A strip chart takes in a stream of floats and produces a 1 hour long
             strip-chart as output
             
             Params:
                decim - how much to decimate input to produce 1 SPS
                seconds - how many seconds long is the stripchart vector
          """

          def __init__(self, decim=100,seconds=3600):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='BAA:Strip Chart',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32,seconds)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #
              # How much do we need to average the input to produce a 1SPS
              #  output?
              #
              self.decim = decim
              
              #
              # The stripchart vector itself--must be persistent in the
              #  object instance
              #
              self.strip = [0.0]*seconds
              
              #
              # keeps track of decimation
              #
              self.counter = 0
              
              #
              # We continuously average the input and store it here
              #
              self.avg = 0.0

          def general_work(self, input_items, output_items):
              """take an input item(s), place appropriately in stripchart output"""
       
              #
              # Our averager hasn't been initialized with a
              #  "prime the pump" value?
              # Do it now.
              #
              if (self.avg == 0.0):
                  self.avg = input_items[0][0]
                  self.counter = 0
                  #
                  # Also init the strip-chart to this level
                  #
                  self.strip = [self.avg]*len(self.strip)
              #
              # For each of the input items
              #
              for x in range(len(input_items[0])):
                  #
                  # Effectively we get a N-point moving average
                  # WHere "N" is "decim"
                  #
                  self.avg += input_items[0][x]
                  self.counter += 1
                  
                  #
                  # Time to output an item into the stripchart
                  #
                  if (self.counter >= self.decim):
                      
                      #
                      # Reduce by decim
                      #
                      self.avg /= self.counter
                      
                      #
                      # Use python array notation to effect a quick
                      #  shift of items in the stripchart array
                      #
                      self.strip = [self.avg] + self.strip[:-1]
                      self.counter = 0
                      self.avg = 1.0e-15
              #
              # Stuff output items with the contents of the 
              #  possibly-updated stripchart
              #
              for y in range(len(output_items[0])):
                  output_items[0][y] = self.strip
              
              #
              # Tell scheduler we consumed items
              #
              self.consume(0, len(input_items[0]))
              return len(output_items[0])
    comment: Produces a "stripchart" type vector
    decim: data_rate
    seconds: seconds
  states: {}
- name: stripchart_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """A strip chart takes in a stream of floats and produces a 1 hour long
             strip-chart as output
             
             Params:
                decim - how much to decimate input to produce 1 SPS
                seconds - how many seconds long is the stripchart vector
          """

          def __init__(self, decim=100,seconds=3600):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='BAA:Strip Chart',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32,seconds)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #
              # How much do we need to average the input to produce a 1SPS
              #  output?
              #
              self.decim = decim
              
              #
              # The stripchart vector itself--must be persistent in the
              #  object instance
              #
              self.strip = [0.0]*seconds
              
              #
              # keeps track of decimation
              #
              self.counter = 0
              
              #
              # We continuously average the input and store it here
              #
              self.avg = 0.0

          def general_work(self, input_items, output_items):
              """take an input item(s), place appropriately in stripchart output"""
       
              #
              # Our averager hasn't been initialized with a
              #  "prime the pump" value?
              # Do it now.
              #
              if (self.avg == 0.0):
                  self.avg = input_items[0][0]
                  self.counter = 0
                  #
                  # Also init the strip-chart to this level
                  #
                  self.strip = [self.avg]*len(self.strip)
              #
              # For each of the input items
              #
              for x in range(len(input_items[0])):
                  #
                  # Effectively we get a N-point moving average
                  # WHere "N" is "decim"
                  #
                  self.avg += input_items[0][x]
                  self.counter += 1
                  
                  #
                  # Time to output an item into the stripchart
                  #
                  if (self.counter >= self.decim):
                      
                      #
                      # Reduce by decim
                      #
                      self.avg /= self.counter
                      
                      #
                      # Use python array notation to effect a quick
                      #  shift of items in the stripchart array
                      #
                      self.strip = [self.avg] + self.strip[:-1]
                      self.counter = 0
                      self.avg = 1.0e-15
              #
              # Stuff output items with the contents of the 
              #  possibly-updated stripchart
              #
              for y in range(len(output_items[0])):
                  output_items[0][y] = self.strip
              
              #
              # Tell scheduler we consumed items
              #
              self.consume(0, len(input_items[0]))
              return len(output_items[0])
    comment: Produces a "stripchart" type vector
    decim: data_rate
    seconds: seconds
  states: {}
- name: stripchart_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """A strip chart takes in a stream of floats and produces a 1 hour long
             strip-chart as output
             
             Params:
                decim - how much to decimate input to produce 1 SPS
                seconds - how many seconds long is the stripchart vector
          """

          def __init__(self, decim=100,seconds=3600):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='BAA:Strip Chart',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32,seconds)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #
              # How much do we need to average the input to produce a 1SPS
              #  output?
              #
              self.decim = decim
              
              #
              # The stripchart vector itself--must be persistent in the
              #  object instance
              #
              self.strip = [0.0]*seconds
              
              #
              # keeps track of decimation
              #
              self.counter = 0
              
              #
              # We continuously average the input and store it here
              #
              self.avg = 0.0

          def general_work(self, input_items, output_items):
              """take an input item(s), place appropriately in stripchart output"""
       
              #
              # Our averager hasn't been initialized with a
              #  "prime the pump" value?
              # Do it now.
              #
              if (self.avg == 0.0):
                  self.avg = input_items[0][0]
                  self.counter = 0
                  #
                  # Also init the strip-chart to this level
                  #
                  self.strip = [self.avg]*len(self.strip)
              #
              # For each of the input items
              #
              for x in range(len(input_items[0])):
                  #
                  # Effectively we get a N-point moving average
                  # WHere "N" is "decim"
                  #
                  self.avg += input_items[0][x]
                  self.counter += 1
                  
                  #
                  # Time to output an item into the stripchart
                  #
                  if (self.counter >= self.decim):
                      
                      #
                      # Reduce by decim
                      #
                      self.avg /= self.counter
                      
                      #
                      # Use python array notation to effect a quick
                      #  shift of items in the stripchart array
                      #
                      self.strip = [self.avg] + self.strip[:-1]
                      self.counter = 0
                      self.avg = 1.0e-15
              #
              # Stuff output items with the contents of the 
              #  possibly-updated stripchart
              #
              for y in range(len(output_items[0])):
                  output_items[0][y] = self.strip
              
              #
              # Tell scheduler we consumed items
              #
              self.consume(0, len(input_items[0]))
              return len(output_items[0])
    comment: Produces a "stripchart" type vector
    decim: data_rate
    seconds: seconds
  states: {}
- name: tinteg
  id: parameter
  parameters:
    label: Integraton Time(secs) for TP
    type: eng_float
    value: '45'
  states: {}
- name: title
  id: parameter
  parameters:
    label: '"Title"'
    type: str
    value: '"BAA Seminar"'
  states: {}
- name: utc
  id: parameter
  parameters:
    label: Log in UTC time
    type: intx
    value: '1'
  states: {}
- name: vectorlogger
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import ra_funcs

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Logging of vectors (like FFT outputs)
                fftsize - size of fft vector to log
                formetter - formatter function pointer
                filepat - pattern for beginning of filenaem
                extension - file extension
                logtime - how often to log (seconds)
                fmtstr - format string for data values
                localtime - whether to use local or UTC time
                fftshift - whether to shift FFT vector before logging
                longitude  - local longitude in decimal form
          """

          def __init__(self, fftsize=2048, formatter=None, filepat="foonly-%04d%02d%02d", extension=".csv",
              logtime=10, fmtstr="%11.9f", localtime=False, fftshift=False,longitude=-76.03):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BAA:Vector Logger',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              
              self.formatter = formatter
              self.filepat = filepat
              self.extension = extension
              self.logtime = logtime
              self.fmtstr = fmtstr
              self.localtime = localtime
              self.vecavg = np.zeros(fftsize)
              self.now = time.time()
              self.fftshift = fftshift
              self.longitude = longitude

              

          def work(self, input_items, output_items):
              """Log a vector into a file"""
              for x in range(len(input_items[0])):
                  self.vecavg = np.add(self.vecavg, input_items[0][x])
                  self.vecavg = np.divide(self.vecavg, [2.0]*len(self.vecavg))
              
              #
              # If time to log
              #
              if (time.time() - self.now >= self.logtime):
                  self.now = time.time()
                  #
                  # Decide on localtime or gmtime
                  #
                  if (self.localtime == True):
                      ltp = time.localtime()
                  else:
                      ltp = time.gmtime()
                  
                  #
                  # If they specified a formatter function call it instead
                  #
                  if (self.formatter != None):
                      self.formatter(self.vecavg,self.filepat,self.extension)
                  
                  #
                  # Otherwise, do it here
                  #
                  else:
                      #
                      # Open the output file, with a name according to the filepat
                      #  specified
                      #
                      fp = open(self.filepat % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday) + self.extension, "a")
                      
                      #
                      # Write record header
                      #
                      fp.write ("%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                      fp.write ("%s," % ra_funcs.cur_sidereal(self.longitude))
                      
                      #
                      # Write each of the data items in the input vector
                      #
                      
                      #
                      # Check if they want us to  do an FFTSHIFT operation
                      #  (to  normalize the ordering of FFTW3 outputs)
                      #
                      if (self.fftshift == True):
                          l = len(self.vecavg)
                          l1 = list(self.vecavg[int(l/2):])
                          l2 = list(self.vecavg[0:int(l/2)])
                          lout = l1 + l2
                          lout = np.array(lout)
                      else:
                          lout = self.vecavg
                      for x in range(len(self.vecavg)):
                          fp.write(self.fmtstr % lout[x])
                          if (x < len(self.vecavg)-1):
                              fp.write(",")
                      fp.write("\n")
                      fp.close()
                  
                  
              return len(input_items[0])
    extension: '''.csv'''
    fftshift: 'False'
    fftsize: fftsize
    filepat: prefix+'fft-0-%04d%02d%02d'
    fmtstr: '''%6.2f'''
    formatter: None
    localtime: False if utc != 0 else True
    logtime: logtime*3
    longitude: longitude
  states: {}
- name: vectorlogger_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import ra_funcs

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Logging of vectors (like FFT outputs)
                fftsize - size of fft vector to log
                formetter - formatter function pointer
                filepat - pattern for beginning of filenaem
                extension - file extension
                logtime - how often to log (seconds)
                fmtstr - format string for data values
                localtime - whether to use local or UTC time
                fftshift - whether to shift FFT vector before logging
                longitude  - local longitude in decimal form
          """

          def __init__(self, fftsize=2048, formatter=None, filepat="foonly-%04d%02d%02d", extension=".csv",
              logtime=10, fmtstr="%11.9f", localtime=False, fftshift=False,longitude=-76.03):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BAA:Vector Logger',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              
              self.formatter = formatter
              self.filepat = filepat
              self.extension = extension
              self.logtime = logtime
              self.fmtstr = fmtstr
              self.localtime = localtime
              self.vecavg = np.zeros(fftsize)
              self.now = time.time()
              self.fftshift = fftshift
              self.longitude = longitude

              

          def work(self, input_items, output_items):
              """Log a vector into a file"""
              for x in range(len(input_items[0])):
                  self.vecavg = np.add(self.vecavg, input_items[0][x])
                  self.vecavg = np.divide(self.vecavg, [2.0]*len(self.vecavg))
              
              #
              # If time to log
              #
              if (time.time() - self.now >= self.logtime):
                  self.now = time.time()
                  #
                  # Decide on localtime or gmtime
                  #
                  if (self.localtime == True):
                      ltp = time.localtime()
                  else:
                      ltp = time.gmtime()
                  
                  #
                  # If they specified a formatter function call it instead
                  #
                  if (self.formatter != None):
                      self.formatter(self.vecavg,self.filepat,self.extension)
                  
                  #
                  # Otherwise, do it here
                  #
                  else:
                      #
                      # Open the output file, with a name according to the filepat
                      #  specified
                      #
                      fp = open(self.filepat % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday) + self.extension, "a")
                      
                      #
                      # Write record header
                      #
                      fp.write ("%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                      fp.write ("%s," % ra_funcs.cur_sidereal(self.longitude))
                      
                      #
                      # Write each of the data items in the input vector
                      #
                      
                      #
                      # Check if they want us to  do an FFTSHIFT operation
                      #  (to  normalize the ordering of FFTW3 outputs)
                      #
                      if (self.fftshift == True):
                          l = len(self.vecavg)
                          l1 = list(self.vecavg[int(l/2):])
                          l2 = list(self.vecavg[0:int(l/2)])
                          lout = l1 + l2
                          lout = np.array(lout)
                      else:
                          lout = self.vecavg
                      for x in range(len(self.vecavg)):
                          fp.write(self.fmtstr % lout[x])
                          if (x < len(self.vecavg)-1):
                              fp.write(",")
                      fp.write("\n")
                      fp.close()
                  
                  
              return len(input_items[0])
    extension: '''.csv'''
    fftshift: 'False'
    fftsize: fftsize
    filepat: prefix+'fft-1-%04d%02d%02d'
    fmtstr: '''%6.2f'''
    formatter: None
    localtime: False if utc != 0 else True
    logtime: logtime*3
    longitude: longitude
  states: {}
- name: velocity
  id: parameter
  parameters:
    label: Show velocities
    type: intx
    value: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rf1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rf2
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: fft1_out
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: fft2_out
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: sum_out
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: corr_out
  states: {}
- name: virtual_sink_2_1
  id: virtual_sink
  parameters:
    stream_id: diff_out
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: tp_east
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: tp_west
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rf1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: rf1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: rf1
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: rf2
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: rf2
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: rf2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: fft1_out
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: fft2_out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: sum_out
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: diff_out
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: corr_out
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: tp_east
  states: {}
- name: virtual_source_5_0
  id: virtual_source
  parameters:
    stream_id: tp_west
  states: {}

connections:
- [baseline_compensate, '0', blocks_nlog10_ff_0, '0']
- [baseline_compensate_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_add_const_vxx_0, '0', baseline_compensate_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_multiply_const_xx_1, '0']
- [blocks_add_const_vxx_1_0, '0', blocks_multiply_const_xx_1_0, '0']
- [blocks_add_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_add_xx_0, '0', pacer_probe, '0']
- [blocks_complex_to_float_0, '0', blocks_patterned_interleaver_0, '1']
- [blocks_complex_to_float_0, '0', stripchart_0, '0']
- [blocks_complex_to_float_0, '1', blocks_patterned_interleaver_0, '2']
- [blocks_complex_to_float_0, '1', stripchart_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_1, '0']
- [blocks_complex_to_mag_squared_1, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_complex_to_mag_squared_1_0, '0', single_pole_iir_filter_xx_1_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_integrate_xx_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_integrate_xx_0_0, '0', single_pole_iir_filter_xx_0_0_0, '0']
- [blocks_integrate_xx_0_1, '0', blocks_multiply_const_xx_0_1, '0']
- [blocks_keep_one_in_n_0, '0', virtual_sink_2, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_keep_one_in_n_0_1, '0', virtual_sink_2_1, '0']
- [blocks_keep_one_in_n_0_2, '0', blocks_patterned_interleaver_0, '4']
- [blocks_keep_one_in_n_0_2, '0', stripchart_1_0, '0']
- [blocks_keep_one_in_n_0_2_0, '0', blocks_patterned_interleaver_0, '5']
- [blocks_keep_one_in_n_0_2_0, '0', stripchart_1_0_0, '0']
- [blocks_keep_one_in_n_1, '0', baseline_compensate, '0']
- [blocks_keep_one_in_n_1_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', blocks_integrate_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_2_0, '0']
- [blocks_multiply_const_xx_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_multiply_const_xx_0_1, '0', single_pole_iir_filter_xx_0_1, '0']
- [blocks_multiply_const_xx_1, '0', virtual_sink_0, '0']
- [blocks_multiply_const_xx_1_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_xx_2, '0', blocks_sub_xx_1_0, '1']
- [blocks_nlog10_ff_0, '0', virtual_sink_1, '0']
- [blocks_nlog10_ff_0_0, '0', virtual_sink_1_0, '0']
- [blocks_patterned_interleaver_0, '0', formatter, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_sub_xx_1, '0', blocks_sub_xx_1_0, '0']
- [blocks_sub_xx_1, '0', single_pole_iir_filter_xx_0_1_0, '0']
- [blocks_sub_xx_1_0, '0', blocks_keep_one_in_n_0_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_1_0, '0']
- [flipper, '0', qtgui_vector_sink_f_1, '0']
- [flipper, '0', vectorlogger, '0']
- [flipper_0, '0', qtgui_vector_sink_f_1, '1']
- [flipper_0, '0', vectorlogger_0, '0']
- [osmosdr_source_0, '0', blocks_add_const_vxx_1, '0']
- [osmosdr_source_0, '1', blocks_add_const_vxx_1_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_add_xx_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_1, '0']
- [single_pole_iir_filter_xx_0, '0', virtual_sink_3, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_sub_xx_0, '0']
- [single_pole_iir_filter_xx_0_0_0, '0', blocks_sub_xx_0, '1']
- [single_pole_iir_filter_xx_0_1, '0', blocks_add_xx_0, '1']
- [single_pole_iir_filter_xx_0_1, '0', blocks_sub_xx_1, '1']
- [single_pole_iir_filter_xx_0_1, '0', virtual_sink_3_0, '0']
- [single_pole_iir_filter_xx_0_1_0, '0', blocks_multiply_const_xx_2, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_keep_one_in_n_1, '0']
- [single_pole_iir_filter_xx_1_0, '0', blocks_keep_one_in_n_1_0, '0']
- [stripchart, '0', qtgui_vector_sink_f_0, '0']
- [stripchart_0, '0', qtgui_vector_sink_f_0_0, '0']
- [stripchart_0_0, '0', qtgui_vector_sink_f_0_0, '1']
- [stripchart_1, '0', qtgui_vector_sink_f_0, '1']
- [stripchart_1_0, '0', qtgui_vector_sink_f_0, '2']
- [stripchart_1_0_0, '0', qtgui_vector_sink_f_0, '3']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0_0_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [virtual_source_0_0_0_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [virtual_source_0_0_1, '0', blocks_complex_to_mag_squared_0_0, '0']
- [virtual_source_0_1, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_1, '0', flipper, '0']
- [virtual_source_1_0, '0', flipper_0, '0']
- [virtual_source_2, '0', blocks_patterned_interleaver_0, '0']
- [virtual_source_2, '0', stripchart, '0']
- [virtual_source_2_0, '0', blocks_patterned_interleaver_0, '3']
- [virtual_source_2_0, '0', stripchart_1, '0']
- [virtual_source_3, '0', blocks_complex_to_float_0, '0']
- [virtual_source_5, '0', blocks_keep_one_in_n_0_2, '0']
- [virtual_source_5_0, '0', blocks_keep_one_in_n_0_2_0, '0']

metadata:
  file_format: 1
