options:
  parameters:
    generate_options: qt_gui
    id: baa_seminar
    output_language: python
    run_options: run
  states: {}

blocks:
- name: data_rate
  id: variable
  parameters:
    comment: |-
      The "back end" operates at this many Hz
      10Hz should be more than adequate for
      any data-logging requirements for this
      type of observing
    value: '10'
  states: {}
- name: fftsize
  id: variable
  parameters:
    comment: |-
      We make this a variable, but in reality
      Embedded Python blocks
      dont handle runtime vector sizing very well
    value: '2048'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(srate)
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: |-
      A detector
      Computes
      (I^2)+(Q^2)
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      After filtering, we don't need high
      sample rates
      reduce to 'data_rate' Hz
    n: int(samp_rate/data_rate)
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: formatter
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import ra_funcs


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """A slow data textual formatter
                inputs are expected to be science-data
                   Parameters:
                      formatter - pointer to a custom formatter function
                      filepat - pattern used for formatting filename must provide converters for YYYY MM DD
                      extension - filename extension
                      logtime - how often to log, in seconds
                      fmtstr - formatter for data values -- most provide converters for both values
                      nchan - number of interleaved channels on input"""
                      
                      

          def __init__(self, formatter=None, filepat="foonly-%d%d%d", extension=".csv", logtime=10,fmtstr="%11.9f",nchan=1,localtime=False,longitude=-76.03):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BAA:Data Logger',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #
              # Formatter is a function pointer--very often 'None'
              #
              self.formatter = formatter
              
              #
              # Controls the template for filename generation
              #
              self.filepat= filepat
              
              #
              # The filename extension
              #
              self.extension=extension
              
              #
              # The logging interval
              #
              self.logtime=logtime
              
              
              #
              # The data-item formatting string
              #      
              self.fmtstr = fmtstr
              
              #
              # How many (interleaved) channels
              self.nchan = nchan
              
              #
              # Use local time, rather than UTC/GMT?
              #
              self.localtime = localtime
              
              #
              # The averaing cells
              #
              self.avg = [0.0]*nchan
              self.acnt = [0]*nchan

              
              #
              # Keep track of the next channel's averaging cell we
              #  need to update
              #
              self.cndx = 0
              
              
              #
              # This isn't strictly required, since the work function code
              #  will take care of whatever items it gets presented with.
              #
              self.set_output_multiple(nchan)
              
              self.now = time.time()
              
              self.longitude = longitude

          def work(self, input_items, output_items):
              
              if (self.localtime == False):
                  ltp = time.gmtime()
              else:
                  ltp = time.localtime()
              
              #
              # Distribute the input items over the averaging buffer as appropriate
              #  We assume that the input is interleaved by 'nchan'
              #  We use 'self.cndx' to keep track of which channel's averaging
              #  cell we need to put the next value in.
              #
              # Because GR's scheduler has no idea what our internal "shape"
              #  is, it can hand us many, or a few, items, every time we're
              #  called.
              #
              for x in range(len(input_items[0])):
                  self.avg[self.cndx % self.nchan] += input_items[0][x]
                  self.acnt[self.cndx % self.nchan] += 1
                  
                  #
                  # Increment and modularly reduce cndx
                  #
                  self.cndx += 1
                  self.cndx %= self.nchan
                  

              if ((time.time() - self.now) > self.logtime):
                  self.now = time.time()
                  if (self.formatter == None):
                      fp = open(self.filepat % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday) + self.extension, "a")
                      fp.write("%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                      fp.write("%s," % ra_funcs.cur_sidereal(self.longitude))
                      for x in range(self.nchan):
                          self.avg[x] /= self.acnt[x]
                          self.acnt[x] = 0
                          fp.write (self.fmtstr  % (self.avg[x]))
                          if (x < self.nchan-1):
                              fp.write(",")
                      fp.write("\n")
                      fp.close()
                  else:
                      self.formatter(self.filepat,self.extension,self.avg[0],self.avg[1])
                  
              return len(input_items[0])
    extension: '''.csv'''
    filepat: '''tp-%04d%02d%02d'''
    fmtstr: '''%11.9f'''
    formatter: None
    localtime: 'True'
    logtime: '3'
    longitude: longitude
    nchan: '1'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: RF Frequency (Hz)
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import ra_funcs
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: 1.0/(samp_rate/fftsize/10)
    fft_size: fftsize
    frame_rate: data_rate
    ref_scale: '2'
    sample_rate: samp_rate
    type: complex
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: Longitude
    type: eng_float
    value: '-76.03'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0 rtl=1
    bb_gain0: '20'
    bb_gain1: '20'
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: freq
    freq1: freq
    gain0: rfgain
    gain1: rfgain
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    iq_balance_mode1: '0'
    nchan: '2'
    num_mboards: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: freq
    fftsize: fftsize
    grid: 'True'
    label: Power
    name: RF Spectrum
    type: complex
    update_time: 1.0/data_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    name: Total Power
    showports: 'True'
    update_time: '0.250'
    vlen: '3600'
    x_axis_label: '"Time (Seconds)"'
    x_start: '0'
    x_step: '1'
    y_axis_label: '"Detector Power"'
    ymax: '1.5'
    ymin: '0'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain (dB)
    type: eng_float
    value: '40'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(samp_rate*3)
    comment: A simple filter/integrator
    type: float
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate (SPS)
    type: eng_float
    value: 2.56e6
  states: {}
- name: stripchart
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """A strip chart takes in a stream of floats and produces a 1 hour long
             strip-chart as output
             
             Params:
                decim - how much to decimate input to produce 1 SPS"""

          def __init__(self, decim=100):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='BAA:Strip Chart',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[(np.float32,3600)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              #
              # How much do we need to average the input to produce a 1SPS
              #  output?
              #
              self.decim = decim
              
              #
              # The stripchart vector itself--must be persistent in the
              #  object instance
              #
              self.strip = [0.0]*3600
              
              #
              # keeps track of decimation
              #
              self.counter = 0
              
              #
              # We continuously average the input and store it here
              #
              self.avg = 0.0

          def general_work(self, input_items, output_items):
              """take an input item(s), place appropriately in stripchart output"""
              #
              # For each of the input items
              #
              if (self.avg == 0.0):
                  self.avg = input_items[0][0]
                  self.strip = [self.avg]*len(self.strip)

              for x in range(len(input_items[0])):
                  #
                  # Two-point moving average for now
                  #
                  self.avg += input_items[0][x]
                  self.counter += 1
                  
                  #
                  # Time to output an item into the stripchart
                  #
                  if (self.counter >= self.decim):
                      self.avg /= self.decim
                      
                      #
                      # Use python array notation to effect a quick
                      #  shift of items in the stripchart array
                      #
                      self.strip = [self.avg] + self.strip[:-1]
                      self.counter = 0
              #
              # Stuff output items with the contents of the stripchart
              #
              for y in range(len(output_items[0])):
                  for x in range(len(self.strip)):
                      output_items[0][y][x] = self.strip[x]
              
              #
              # Tell scheduler we consumed items
              #
              self.consume(0, len(input_items[0]))
              return len(output_items[0])
    comment: Produces a "stripchart" type vector
    decim: data_rate
  states: {}
- name: vectorlogger
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import ra_funcs

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Logging of vectors (like FFT outputs)"""

          def __init__(self, fftsize=2048, formatter=None, filepat="foonly-%04d%02d%02d", extension=".csv",
              logtime=10, fmtstr="%11.9f", localtime=False, fftshift=True,longitude=-76.03):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BAA:Vector Logger',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              
              self.formatter = formatter
              self.filepat = filepat
              self.extension = extension
              self.logtime = logtime
              self.fmtstr = fmtstr
              self.localtime = localtime
              self.vecavg = np.zeros(fftsize)
              self.now = time.time()
              self.fftshift = fftshift
              self.longitude = longitude

              

          def work(self, input_items, output_items):
              """Log a vector into a filet"""
              for x in range(len(input_items[0])):
                  self.vecavg = np.add(self.vecavg, input_items[0][x])
                  self.vecavg = np.divide(self.vecavg, [2.0]*len(self.vecavg))
              
              #
              # If time to log
              #
              if (time.time() - self.now >= self.logtime):
                  self.now = time.time()
                  #
                  # Decide on localtime or gmtime
                  #
                  if (self.localtime == True):
                      ltp = time.localtime()
                  else:
                      ltp = time.gmtime()
                  
                  #
                  # If they specified a formatter function call it instead
                  #
                  if (self.formatter != None):
                      self.formatter(self.vecavg,self.filepat,self.extension)
                  
                  #
                  # Otherwise, do it here
                  #
                  else:
                      #
                      # Open the output file, with a name according to the filepat
                      #  specified
                      #
                      fp = open(self.filepat % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday) + self.extension, "a")
                      
                      #
                      # Write record header
                      #
                      fp.write ("%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                      fp.write ("%s" % ra_funcs.cur_sidereal(self.longitude))
                      
                      #
                      # Write each of the data items in the input vector
                      #
                      
                      #
                      # Check if they want us to  do an FFTSHIFT operation
                      #  (to  normalize the ordering of FFTW3 outputs)
                      #
                      if (self.fftshift == True):
                          l = len(self.vecavg)
                          l1 = list(self.vecavg[int(l/2):])
                          l2 = list(self.vecavg[0:int(l/2)])
                          lout = l1 + l2
                          lout = np.array(lout)
                      else:
                          lout = self.vecavg
                      for x in range(len(self.vecavg)):
                          fp.write(self.fmtstr % lout[x])
                          if (x < len(self.vecavg)-1):
                              fp.write(",")
                      fp.write("\n")
                      fp.close()
                  
                  
              return len(input_items[0])
    extension: '''.csv'''
    fftshift: 'True'
    fftsize: fftsize
    filepat: '''fft-0-%04d%02d%02d'''
    fmtstr: '''%6.2f'''
    formatter: None
    localtime: 'False'
    logtime: '10'
    longitude: longitude
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', formatter, '0']
- [blocks_keep_one_in_n_0, '0', stripchart, '0']
- [logpwrfft_x_0, '0', vectorlogger, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', logpwrfft_x_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '1', blocks_null_sink_1, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [stripchart, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
